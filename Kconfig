## Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
config RTL8822CS
	tristate "Realtek 8822C SDIO WiFi"
	help
	  Help message of RTL8822CS
```
